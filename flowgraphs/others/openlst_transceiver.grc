options:
  parameters:
    generate_options: no_gui
    id: openlst_transceiver
    output_language: python
    title: OpenLST Transceiver
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '7415.77'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 437e6
  states: {}
- name: offset
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/bit_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ryan/Desktop/dora_heartbeat_jan.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-offset'
    sample_rate: samp_rate
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: resamp_rate
    resamp_type: digital.IR_MMSE_8TAP
    sps: resamp_rate
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resamp_rate/samp_per_sym
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_per_sym/resamp_rate
    type: complex
  states: {}
- name: openlst_openlst_demod_0
  id: openlst_openlst_demod
  parameters:
    fec: 'True'
    flags: '0'
    flags_mask: '0x80'
    preamble_bytes: '4'
    preamble_quality: '30'
    sync_byte0: 0X91
    sync_byte1: '0xD3'
    sync_words: '2'
    whitening: 'True'
  states: {}
- name: openlst_openlst_mod_0
  id: openlst_openlst_mod
  parameters:
    bitrate: '7415.77'
    fec: 'True'
    flags: '0xC0'
    max_latency: '0.1'
    preamble_bytes: '4'
    sync_byte0: '0x91'
    sync_byte1: '0xD3'
    sync_words: '2'
    whitening: 'True'
  states: {}
- name: openlst_raw_zmq_sink_0
  id: openlst_raw_zmq_sink
  parameters:
    socket_path: ipc:///tmp/openlst_rx
    socket_type: PUB
  states: {}
- name: openlst_raw_zmq_source_0
  id: openlst_raw_zmq_source
  parameters:
    socket_path: ipc:///tmp/openlst_tx
    socket_type: PULL
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq-offset
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq-offset
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_freqshift_cc_0_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_freqshift_cc_0_0_0, '0', low_pass_filter_0, '0']
- [digital_gfsk_demod_0, '0', openlst_openlst_demod_0, '0']
- [digital_gfsk_mod_0, '0', mmse_resampler_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_freqshift_cc_0_0, '0']
- [mmse_resampler_xx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [openlst_openlst_demod_0, message, openlst_raw_zmq_sink_0, message]
- [openlst_openlst_mod_0, '0', digital_gfsk_mod_0, '0']
- [openlst_raw_zmq_source_0, message, openlst_openlst_mod_0, message]
- [soapy_rtlsdr_source_0, '0', blocks_freqshift_cc_0_0_0, '0']

metadata:
  file_format: 1
