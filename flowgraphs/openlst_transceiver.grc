options:
  parameters:
    author: Ryan Skabelund
    generate_options: qt_gui
    id: openlst_transceiver
    output_language: python
    title: OpenLST Transceiver
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '7415.77'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 436.825e6
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_per_sym_hackrf
  id: variable
  parameters:
    value: samp_rate_hackrf/bit_rate
  states: {}
- name: samp_per_sym_rtl_sdr
  id: variable
  parameters:
    value: samp_rate_rtl_sdr/bit_rate
  states: {}
- name: samp_rate_hackrf
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_rtl_sdr
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: tcp_address
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../output/received_transmission
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: ../output/sent_transmission
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ryan/Desktop/dora_heartbeat_jan.iq
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/ryan/gr-dora/output/INPUT_set_radio_transmission_state
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_rtl_sdr
    type: complex
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: resamp_rate
    resamp_type: digital.IR_MMSE_8TAP
    sps: resamp_rate
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: cc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_rtl_sdr
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_per_sym_rtl_sdr/resamp_rate
    type: complex
  states: {state: disabled}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resamp_rate/samp_per_sym_hackrf
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: tcp_port
    type: byte
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: tcp_port
    server: 'False'
    type: byte
  states: {state: disabled}
- name: openlst_openlst_demod_0
  id: openlst_openlst_demod
  parameters:
    fec: 'True'
    flags: '0'
    flags_mask: '0x80'
    preamble_bytes: '4'
    preamble_quality: '30'
    sync_byte0: 0X91
    sync_byte1: '0xD3'
    sync_words: '2'
    whitening: 'True'
  states: {state: disabled}
- name: openlst_openlst_mod_0
  id: openlst_openlst_mod
  parameters:
    fec: 'True'
    flags: '192'
    preamble_bytes: '4'
    seq_byte0: '105'
    seq_byte1: '34'
    sync_byte0: '145'
    sync_byte1: '211'
    sync_words: '2'
    whitening: 'True'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_rtl_sdr
    fc: '0'
    fftsize: '1024'
    name: '"Receiver"'
    type: complex
    update_time: '0.075'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_hackrf
    fc: '0'
    fftsize: '1024'
    name: '"Transmitter"'
    type: complex
    update_time: '0.001'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate_hackrf
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate_rtl_sdr
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1, '0', openlst_openlst_mod_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', openlst_openlst_demod_0, '0']
- [digital_gfsk_mod_0, '0', mmse_resampler_xx_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [mmse_resampler_xx_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [mmse_resampler_xx_1, '0', soapy_hackrf_sink_0, '0']
- [network_tcp_source_0, '0', openlst_openlst_mod_0, '0']
- [openlst_openlst_demod_0, '0', blocks_file_sink_0, '0']
- [openlst_openlst_demod_0, '0', network_tcp_sink_0, '0']
- [openlst_openlst_mod_0, '0', blocks_file_sink_1, '0']
- [openlst_openlst_mod_0, '0', digital_gfsk_mod_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
